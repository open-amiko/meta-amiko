KV = "4.10.6"
SRCDATE = "20170917"

require amiko-dvb-modules.inc

SRC_URI[md5sum] = "6c1ad552840abfcfd4159d325dcee874"
SRC_URI[sha256sum] = "6726927583c1cbe5cc978809df97cfc1c813529c77f86c7f6980a9e2b09d8853"

COMPATIBLE_MACHINE = "vipert2c"
