KV = "4.10.6"
SRCDATE = "20170917"

require amiko-dvb-modules.inc

SRC_URI[md5sum] = "83fc0dac2972e0f451bb264beac55b26"
SRC_URI[sha256sum] = "5d56f7cf0deeaeff30e3837640f24fe55098c205288c0b9058d1e039b3c1ae41"

COMPATIBLE_MACHINE = "vipercombo"
