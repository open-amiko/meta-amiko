KV = "4.10.6"
SRCDATE = "20171225"

require amiko-dvb-modules.inc

SRC_URI[md5sum] = "dac914e770e308b6b6e2e13a45824a7b"
SRC_URI[sha256sum] = "a16f54f2fd472a0bc9a83d696e5c6a824cfefe34bde0af3bee869674ad530114"

COMPATIBLE_MACHINE = "vipercombohdd"
